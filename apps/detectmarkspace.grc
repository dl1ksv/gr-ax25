options:
  parameters:
    category: '[DL1KSV]/Tools'
    generate_options: hb
    id: detectMarkSpace
    output_language: python
  states: {}

blocks:
- name: Baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: Atcout
  id: pad_sink
  parameters:
    label: Corrected
    optional: 'True'
    type: float
  states: {}
- name: Atcout_0
  id: pad_sink
  parameters:
    label: UnCorrected
    optional: 'True'
    type: float
  states: {}
- name: Frequency
  id: parameter
  parameters:
    type: eng_float
    value: '1200'
  states: {}
- name: Input
  id: pad_source
  parameters:
    label: In
    type: float
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: attack
    decay_rate: decay
    gain: '1.0'
    max_gain: '1.0'
    reference: '1.0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-Frequency'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: attack
  id: parameter
  parameters:
    label: Attack
    value: '0.1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: decay
  id: parameter
  parameters:
    label: Decay
    value: '0.001'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: int(samp_rate/Baud)
    samp_rate: samp_rate
    sym_rate: Baud
    type: fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '48000'
  states: {}

connections:
- [Input, '0', blocks_float_to_complex_0, '0']
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', Atcout_0, '0']
- [blocks_complex_to_mag_0, '0', analog_agc2_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_sub_xx_0, '0', Atcout, '0']
- [blocks_sub_xx_0, '0', blocks_null_sink_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
