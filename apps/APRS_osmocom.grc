<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>APRS_osmocom</value></param>
<param><key>author</key><value>dl1ksv, kj6gve</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Receives ax.25 packets , display the packets, and converts aprs packet to be send via tcp/ip</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receives ax.25/ aprs packets</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Attack</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>BBGain</value></param>
<param><key>comment</key><value>hackrf: 0-62/2
airspy: 0-14/1</value></param>
<param><key>value</key><value>32</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>62</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Band</value></param>
<param><key>value</key><value>144.39e6</value></param>
<param><key>gui_hint</key><value>0,0,2,1</value></param>
<param><key>label0</key><value>"APRS (US)"</value></param>
<param><key>label1</key><value>"APRS (Intl)"</value></param>
<param><key>label2</key><value>"ISS"</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>144.39e6</value></param>
<param><key>option1</key><value>144.8e6</value></param>
<param><key>option2</key><value>145.819e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Decay</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>FineTuning</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1 * audio_rate</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value> audio_rate</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>IFGain</value></param>
<param><key>comment</key><value>hackrf: 0-40/8
airspy: 0-14/1</value></param>
<param><key>value</key><value>32</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>MonitorGain</value></param>
<param><key>comment</key><value>hackrf: 0-14/14
airspy: 0-14/1</value></param>
<param><key>value</key><value>0.02</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RFGain</value></param>
<param><key>comment</key><value>hackrf: 0-14/14
airspy: 0-14/1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>14</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TunerOffset</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>int(48e3)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>decimation_lpf</value></param>
<param><key>cutoff_freq</key><value>12.5e3</value></param>
<param><key>gain</key><value>1.5</value></param>
<param><key>samp_rate</key><value>radio_rate</value></param>
<param><key>width</key><value>25e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_lpf_len</value></param>
<param><key>comment</key><value>Number of taps needed to
filter and decimate. Width
of the transition band (roll
off vs brick wall) is biggest
factor here. You may have
poor performance (dropped
samples, high cpu load) if
the number of taps gets too
large. Less than 250 is good.</value></param>
<param><key>value</key><value>len(decimation_lpf)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>intermediate_rate</value></param>
<param><key>value</key><value>radio_rate / radio_decimation</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>cutoff_freq</key><value>4.9e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>monitor_enable</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,4</value></param>
<param><key>label0</key><value>Off</value></param>
<param><key>label1</key><value>On</value></param>
<param><key>label</key><value>Audio Monitor</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_decimation</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_rate</value></param>
<param><key>value</key><value>int(2.5e6)</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Display</value></param>
<param><key>gui_hint</key><value>2,0,1,7</value></param>
<param><key>label0</key><value>Monitor</value></param>
<param><key>label1</key><value>Results</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>afsk_afsk1200</key>
<param><key>id</key><value>afsk_afsk1200_0</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>sample_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>afsk_aprs2inet</key>
<param><key>id</key><value>afsk_aprs2inet_0</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>sample_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>afsk_ax25decode</key>
<param><key>id</key><value>afsk_ax25decode_1</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>sample_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>2450</value></param>
<param><key>low_cutoff_freq</key><value>950</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>server</key><value>True</value></param>
<param><key>port</key><value>32000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>monitor_enable * MonitorGain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>detectMarkSpace</key>
<param><key>id</key><value>detectMarkSpace_0_0</value></param>
<param><key>attack</key><value>Attack</value></param>
<param><key>decay</key><value>Decay</value></param>
<param><key>Frequency</key><value>1200</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>detectMarkSpace</key>
<param><key>id</key><value>detectMarkSpace_1_0</value></param>
<param><key>attack</key><value>Attack</value></param>
<param><key>decay</key><value>Decay</value></param>
<param><key>Frequency</key><value>2200</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>TunerOffset</value></param>
<param><key>decim</key><value>radio_decimation</value></param>
<param><key>samp_rate</key><value>radio_rate</value></param>
<param><key>taps</key><value>decimation_lpf</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>BBGain</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>Band - TunerOffset + FineTuning*1e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>IFGain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>RFGain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>radio_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>Band</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>Display@0:0,0</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>intermediate_rate</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0_0_0</value></param>
<param><key>gui_hint</key><value>Display@1:0,0</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0_0_0_0</value></param>
<param><key>gui_hint</key><value>Display@1:0,1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>audio</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>audio</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>audio</value></param>
</block>
<connection><source_block_id>afsk_afsk1200_0</source_block_id><sink_block_id>show_text_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>afsk_aprs2inet_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>afsk_ax25decode_1</source_block_id><sink_block_id>show_text_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>afsk_afsk1200_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>detectMarkSpace_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>detectMarkSpace_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0_0</source_block_id><sink_block_id>afsk_aprs2inet_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0_0</source_block_id><sink_block_id>afsk_ax25decode_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectMarkSpace_0_0</source_block_id><sink_block_id>blocks_sub_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectMarkSpace_1_0</source_block_id><sink_block_id>blocks_sub_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
