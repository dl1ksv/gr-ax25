options:
  parameters:
    author: dl1ksv
    category: Custom
    description: Receives ax.25 packets , display the packets, and converts aprs packet to be send via tcp/ip
    generate_options: qt_gui
    id: APRS
    output_language: python
    title: Receives ax.25/ aprs packets
  states: {}

blocks:
- name: Attack
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Decay
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: Decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Frequency
  id: variable
  parameters:
    value: '97000'
  states: {}
- name: FrequencyOffset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2
    start: '-20'
    step: '1'
    stop: '20'
    value: '10'
    widget: counter
  states: {}
- name: IFGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    rangeType: int
    start: '1'
    step: '1'
    stop: '25'
    value: '20'
    widget: counter
  states: {}
- name: Modus
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0
    label0: APRS
    label1: ISS
    num_opts: '2'
    option0: '144800'
    option1: '145819'
    type: real
    value: '144800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: Display
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,3
    label0: Settings
    label1: Results
    num_tabs: '2'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/4
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: '48000'
  states: {}
- name: ax25_afsk1200_0
  id: ax25_afsk1200
  parameters:
    debug_level: '2'
    sample_rate: int(samp_rate/4)
  states: {}
- name: ax25_ax25decode_0
  id: ax25_ax25decode
  parameters:
    debug_level: '2'
    sample_rate: int(samp_rate/4)
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2450'
    low_cutoff_freq: '950'
    samp_rate: samp_rate/Decim
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '4'
    gain: '4'
    high_cutoff_freq: FrequencyOffset*500+10000
    low_cutoff_freq: FrequencyOffset*500
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: detectMarkSpace_0_0
  id: detectMarkSpace
  parameters:
    Frequency: '1200'
    attack: Attack
    decay: Decay
    samp_rate: samp_rate/Decim
  states: {}
- name: detectMarkSpace_1_0
  id: detectMarkSpace
  parameters:
    Frequency: '2200'
    attack: Attack
    decay: Decay
    samp_rate: samp_rate/Decim
  states: {}
- name: funcube_fcdpp_0
  id: funcube_fcdpp
  parameters:
    freq: Modus-FrequencyOffset
    if_gain: IFGain
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: '0'
    unit: '1000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4900'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: (Modus-FrequencyOffset)*1000
    fftsize: '1024'
    gui_hint: Display@0:2,0
    name: QT GUI Plot
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    gui_hint: Display@0:3,0
    name: QT GUI Plot
    showports: 'True'
    type: complex
  states: {}
- name: show_text_0_0_0
  id: show_text
  parameters:
    gui_hint: Display@1:0,0
    label: ''
  states: {}
- name: show_text_0_0_0_0
  id: show_text
  parameters:
    gui_hint: Display@1:0,1
    label: ''
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', audio_sink_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', band_pass_filter_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [ax25_afsk1200_0, '0', show_text_0_0_0_0, '0']
- [ax25_ax25decode_0, '0', show_text_0_0_0, '0']
- [band_pass_filter_0_0, '0', ax25_afsk1200_0, '0']
- [band_pass_filter_0_0, '0', detectMarkSpace_0_0, '0']
- [band_pass_filter_0_0, '0', detectMarkSpace_1_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0_0_0, '0', ax25_ax25decode_0, '0']
- [detectMarkSpace_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [detectMarkSpace_1_0, '0', blocks_sub_xx_0_0_0, '1']
- [funcube_fcdpp_0, '0', band_pass_filter_1, '0']
- [funcube_fcdpp_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
