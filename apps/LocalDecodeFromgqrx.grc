options:
  parameters:
    author: dl1ksv
    generate_options: qt_gui
    id: ax25fromgqrx
    output_language: python
    thread_safe_setters: '1'
    title: 'Decode Aprs data from qgrx vio loopbak device '
  states: {}

blocks:
- name: Attack
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Decay
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:2,0
    samp_rate: samp_rate
  states: {}
- name: ax25_afsk1200_0
  id: ax25_afsk1200
  parameters:
    debug_level: '1'
    sample_rate: samp_rate
  states: {}
- name: ax25_ax25decode_0
  id: ax25_ax25decode
  parameters:
    debug_level: '1'
    sample_rate: samp_rate
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2450'
    low_cutoff_freq: '950'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: detectMarkSpace_0_0
  id: detectMarkSpace
  parameters:
    Frequency: '1200'
    attack: Attack
    decay: Decay
    samp_rate: samp_rate
  states: {}
- name: detectMarkSpace_1_0
  id: detectMarkSpace
  parameters:
    Frequency: '2200'
    attack: Attack
    decay: Decay
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: show_text_0_0_0
  id: show_text
  parameters:
    label: Via detectmarkspace
  states: {}
- name: show_text_0_0_0_0
  id: show_text
  parameters:
    label: Direct
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [ax25_afsk1200_0, '0', show_text_0_0_0_0, '0']
- [ax25_ax25decode_0, '0', show_text_0_0_0, '0']
- [band_pass_filter_0_0, '0', ax25_afsk1200_0, '0']
- [band_pass_filter_0_0, '0', detectMarkSpace_0_0, '0']
- [band_pass_filter_0_0, '0', detectMarkSpace_1_0, '0']
- [blocks_sub_xx_0_0_0, '0', ax25_ax25decode_0, '0']
- [detectMarkSpace_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [detectMarkSpace_1_0, '0', blocks_sub_xx_0_0_0, '1']

metadata:
  file_format: 1
